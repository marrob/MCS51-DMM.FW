# Keil uVision project DMM.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C31BH Intel
  cpu: IRAM(0-0x7F) CLOCK(24000000)
  output: DMM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 main.c knvlib.c
